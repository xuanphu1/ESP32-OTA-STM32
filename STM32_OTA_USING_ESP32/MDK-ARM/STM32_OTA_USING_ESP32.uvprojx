# Keil uVision project STM32_OTA_USING_ESP32.uvprojx, settings and files
target STM32_OTA_USING_ESP32 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: STM32_OTA_USING_ESP32 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\Core\Component\Uart_Cli\App_CLI;..\Core\Component\Min;..\Core\Component\Guess_OTA;..\Core\Component\RW_FLASH_MEMORY;..\Core\Component\processing_HEX;..\Core\Component\BootLoader
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Component
    ../Core/Component/Uart_Cli/App_CLI/: response_cli.c
    ../Core/Component/Min/: min.c
    ../Core/Component/Guess_OTA/: OTAGuess_STM32.c
    ../Core/Component/RW_FLASH_MEMORY/: FlashSTM32.c
    ../Core/Component/processing_HEX/: processing_data_of_file_hex.c
    ../Core/Component/BootLoader/: BootLoader.c
software components: CMSIS:CORE 4.3.0
